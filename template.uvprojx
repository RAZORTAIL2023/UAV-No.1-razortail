# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Start;.\Libraries;.\User;.\Core Peripheral;.\Base Peripheral;.\I2C Peripheral;.\SPI Peripheral;.\Algorithm;.\uC-CONFIG;.\uC-CPU;.\uC-LIB;.\uC-OS3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Libraries
    ./Libraries/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h INIT.c INIT.h main.c main.h
  group Base Peripheral
    ./Base Peripheral/: GPIO.c GPIO.h LED.c LED.h
  group Core Peripheral
    ./Core Peripheral/: Timer.c Timer.h EXTI.c EXTI.h NVIC.c NVIC.h ADC.c ADC.h DMA.c DMA.h USART.c USART.h
  group I2C Peripheral
    ./I2C Peripheral/: Inter-Integrated Circuit PREPOSITION.c Inter-Integrated Circuit.c Inter-Integrated Circuit.h MPU6050.c MPU6050.h
    ./i2c peripheral/: I2C interface.c I2C interface.h debugging.c
    ./I2c peripheral/: OLED.c OLED.h
  group SPI Peripheral
    ./: Serial Peripheral Interface.c
    ./spi peripheral/: Serial Peripheral Interface.h nRF24L01.h
    ./SPI PERIPHERAL/: nRF24L01.c
  group Algorithm
    ./algorithm/: PID PREPOSITION.c PID.h Attitude Determination.c Attitude Determination.h motor.c motor.h Calibration.c Calibration.h
    ./Algorithm/: PID.c
  group uC-CONFIG
    ./uC-CONFIG/: cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uC-CPU
    ./uC-CPU/: cpu.h cpu_a.asm cpu_c.c cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group uC-LIB
    ./uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uC-OS3
    ./uC-OS3/: os.h os_cfg_app.c os_core.c os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
